# Keil uVision project STM32.uvprojx, settings and files
target STM32_USART1 (ARM-ADS)
  device: STM32F105RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_CL, USE_STDPERIPH_DRIVER
  c include: .\FWlib\inc;.\user;.\Hardware;.\MyLib;.\FreeRTOS\include;.\FreeRTOS\port\MemMang;.\FreeRTOS\port\RVDS\ARM_CM3;.\FreeRTOS\src;.\user\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./startup/: startup_stm32f10x_cl.s
  group User
    ./user/: main.c stm32f10x_it.c FreeRTOSConfig.h
  group MyLib
    ./MyLib/: can1.c can2.c usart.c led.c delay.c drv_dma.c nvic.c remote.c pid.c algorithmOfCRC.c tim.c
  group StdPeriph_Drive
    ./FWlib/SRC/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_can.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_usart.c stm32f10x_adc.c
  group CMSIS
    ./user/: core_cm3.c system_stm32f10x.c
  group FreeRTOS/Src
    ./FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Ports
    ./FreeRTOS/port/MemMang/: heap_4.c
    ./FreeRTOS/port/RVDS/ARM_CM3/: port.c
  group APP
    ./user/APP/: start_task.c state_task.c
    ./MyLib/: chassis_task.c
